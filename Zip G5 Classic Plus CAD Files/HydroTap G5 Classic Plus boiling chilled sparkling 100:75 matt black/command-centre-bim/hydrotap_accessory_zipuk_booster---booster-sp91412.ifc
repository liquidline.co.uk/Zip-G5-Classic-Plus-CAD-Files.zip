Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2021-09-09T17:04:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.10.28 - Exporter 22.0.10.28 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 09 17:04:48 2021 * Host: DESKTOP-QB16J48 * Database: C:\Users\Glenn\AppData\Local\Temp\b05f7b85-a1d0-447a-9c05-9af200eb2c2b\606f663c-f8e6-4a6a-acc3-c761931f60e9\ifc * Database version: 5507 * Database creation date: Thu Sep 09 17:04:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 09 17:04:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 09 17:04:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -33, -52, -1, -696472; RefLongitude: 151, 12, 25, 587158; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Ground Floor
Pset_ProductRequirements - Name: Ground Floor; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcElementAssembly: Plumbing Fixtures Assembly:HydroTap_Accessory_ZipUK_Booster Booster (SP91412), Plumbing Fixtures Assembly:HydroTap_Accessory_ZipUK_Booster Booster (SP91412):1497642
In: Ground Floor
PredefinedType: USERDEFINED
Pset_ProductRequirements - Category: Assemblies
Pset_QuantityTakeOff - Reference: HydroTap_Accessory_ZipUK_Booster Booster (SP91412)
Identity Data - Naming Category: Plumbing Fixtures
Other - Category: Assemblies; Family: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_Booster Booster (SP91412); Family and Type: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_Booster Booster (SP91412); Type: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_Booster Booster (SP91412); Type Id: Plumbing Fixtures Assembly: HydroTap_Accessory_ZipUK_Booster Booster (SP91412)
Phasing - Phase Created: New Construction
Identity Data(Type) - Type Name: HydroTap_Accessory_ZipUK_Booster Booster (SP91412)
Other(Type) - Category: Assemblies; Family Name: Plumbing Fixtures Assembly

# IfcFlowTerminal: HydroTap_Accessory_ZipUK_Booster:Booster (SP91412), HydroTap_Accessory_ZipUK_Booster:Booster (SP91412):1492179
In: Ground Floor
Type - Material: Metal_PowderCoat_Zip_White
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - BodyDepth: 70 mm; BodyHeight: 135 mm; Manufacturer_Overall Depth: 87 mm; Manufacturer_Overall Height: 154 mm; Manufacturer_Overall Width: 186 mm
Type - Identity Data - CreatedBy_ANZRS: IGS BIM Solutions; CreatedByURL_ANZRS: https://igsgroup.com.au; Description: Capacity Booster for HydroTap Boiling models; Manufacturer: Zip Water UK; Manufacturer_Spec Code: SP91412; Manufacturer_URL__Product Specific: https://specify.zipwater.co.uk/our-ranges/hydrotap; Model: 135H x 186W x 70D - Booster; ModifiedIssue_ANZRS: 20210728; OmniClass Number: 23.21.21.25; Type Comments: Booster; Type Name: Booster (SP91412); Uniclass2015Code: Pr_40_70_23_42; Uniclass2015Title: Instant boiling and cold water taps; Uniclass2015Version: Products v1.17; URL: https://www.zipwater.co.uk/
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: UKCA and CE marked; Color: White; Family Name: HydroTap_Accessory_ZipUK_Booster; Grade: Commercial; Size: 186 x 70 x 135 mm; SustainabilityPerformance: RoHS and WEEE compliant
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Zip Water UK
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: Metal_StainlessSteel_Zip
Pset_DistributionFlowElementCommon - Reference: Booster (SP91412); sets with these values: 2
Constraints - Elevation from Level: 0 mm; ManufacturerHeightFromFFL: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.073214 m2; Volume: 0.00201216 m3
Identity Data - Assembly Name: HydroTap_Accessory_ZipUK_Booster Booster (SP91412); Mark: 192
Other - Family: HydroTap_Accessory_ZipUK_Booster: Booster (SP91412); Family and Type: HydroTap_Accessory_ZipUK_Booster: Booster (SP91412); Type: HydroTap_Accessory_ZipUK_Booster: Booster (SP91412); Type Id: HydroTap_Accessory_ZipUK_Booster: Booster (SP91412)
Phasing - Phase Created: New Construction
